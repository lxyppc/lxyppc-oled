# IAR project oledLoader.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8n.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: STM32; BOOTLOADER
  ICCARM.CCIncludePath2: ; inc; ..\FWLib\inc; ..\USBLib\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm\lnkarm_flash.xcl
configuration Sim (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: STM32
  group inc
    inc/: BootLoader.h bsp.h config.h export.h hw_config.h includes.h stm32f10x_conf.h stm32f10x_it.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h
  group lib/FWLib
    ../FWLib/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group lib/USBLib
    ../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group Link
    lnkarm/: lnkarm_flash.xcl
  group src
    src/: Bootloader.c cortexm3_macro.s hw_config.c main.c stm32f10x_it.c stm32f10x_vector.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
