# IAR project oled.ewp, settings and files
configuration RAM_Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: VECT_TAB_RAM; _STM32_
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\FWLib\inc; inc; ..\GraphicLib\inc; ..\UsbLib\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_ram.xcl
configuration Flash_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: VECT_TAB_FLASH; _STM32_
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\FWLib\inc; inc; ..\GraphicLib\inc
  XLINK.XclFile: lnkarm_flash.xcl
configuration Flash_Hex (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: WITH_BOOTLOADER; _STM32_
  ICCARM.CCIncludePath2: as above
  XLINK.XclFile: lnkarm_flash_withLoader.xcl
  group EWARM
    ./: cortexm3_macro.s
  group FWLib
    ../FWLib/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group GraphicLib/src
    ../GraphicLib/src/: Button.c Chart.c CheckBox.c DigitalMeter.c DisplayDriver.c EditBox.c GOL.c GOLFontDefault.c Grid.c GroupBox.c ListBox.c Meter.c Picture.c Primitive.c ProgressBar.c RadioButton.c RoundDial.c Slider.c StaticText.c Template.c TextEntry.c Window.c
  group Inc
    inc/: bsp.h DrawText.h Encoder.h font.h GraphicsConfig.h HardwareProfile.h Icon.h menu.h SSD1303.h stm32f10x_conf.h stm32f10x_it.h
  group linkScript
    ./: lnkarm_flash.xcl lnkarm_flash_extsram.xcl lnkarm_flash_withLoader.xcl lnkarm_nor.xcl lnkarm_ram.xcl
  group USBLib
    ../oledLoader/inc/: export.h
  group User
    src/: ClockSet.c ColckUI.c DrawText.c Encoder.c font.c Icon.c main.c menu.c SSD1303.c stm32f10x_it.c stm32f10x_vector.c
